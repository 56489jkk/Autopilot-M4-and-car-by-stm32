# Keil uVision project CAR.uvprojx, settings and files
target F103_L298N_test2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: rtthread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User\Motor;..\User\Track;..\User\Ultrasonic;..\User\Usart_printf;..\User\Servo;..\User\LCD;..\User\font;..\User\lcd;..\User\sdram;..\Drivers\STM32F1xx_HAL_Driver\Src;..\User\Blue;..\User\Systick;..\User\pid
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../User/Motor/: bsp_motor.c
    ../User/Track/: bsp_track.c
    ../User/Ultrasonic/: bsp_Hcsro4.c
    ../User/Usart_printf/: bsp_User_Debug.c
    ../User/Servo/: bsp_servo.c
    ../User/font/: fonts.c
    ../User/sdram/: bsp_sdram.c
    ../User/lcd/: bsp_ili9341_lcd.c
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c i2c.c i2c.h
    ../User/Systick/: Systick.c
    ../User/pid/: pid.c
    ../User/gps/: gps.c gps.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_nor.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
